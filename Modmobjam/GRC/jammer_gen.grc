options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: jammer_gen
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    orient: Qt.Horizontal
    start: 2e6
    step: '10'
    stop: 50e6
    value: var_bandwidth
    widget: slider
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB gain
    orient: Qt.Horizontal
    start: '10'
    step: '10'
    stop: '60'
    value: var_bb_gain
    widget: slider
  states: {}
- name: cent_freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: 900e6
    step: '500'
    stop: 2200e6
    value: var_cent_freq
    widget: slider
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    orient: Qt.Horizontal
    start: '10'
    step: '10'
    stop: '60'
    value: var_if_gain
    widget: slider
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    orient: Qt.Horizontal
    start: '10'
    step: '10'
    stop: '60'
    value: var_rf_gain
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample rate
    orient: Qt.Horizontal
    start: 2e6
    step: '10'
    stop: 20e6
    value: samp_rate
    widget: slider
  states: {}
- name: var_bandwidth
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: var_bb_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: var_cent_freq
  id: variable
  parameters:
    value: '1874200000'
  states: {}
- name: var_if_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: var_rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '50'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: '1'
    args: ''
    bb_gain0: bb_gain
    bw0: bandwidth
    freq0: cent_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8888'
  states: {}

connections:
- [analog_noise_source_x_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
